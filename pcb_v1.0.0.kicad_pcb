# Repository BustosNahu/HardwareHuerta

## KiCad design pcb_v1.0.0.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6: DIODE; DO-41
H1, H2, H3, H4: Mounting_Hole; Tornillo_M3_8mm
J1, J2, J5, J7: B-S. Humedad; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J4: B-S. Humedad/Tem.; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J6: B-Bomba; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J8: B-V. In; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J9: B-UV.; BORNERA2_AZUL
J10, J11, J12, J13: B-Elec. Valvulas; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J14, J15: Cable_PAD; PAD_SMD_2x5mm
JQ1: TB_1X2; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
K1, K2, K3, K4, K5, K6: RELAY_C; Relay_C
LED1, LED2, LED3, LED4, LED5, LED6: LED; led_5mm_green
Q1, Q2, Q3, Q4, Q5, Q6: 2N7002; SOT23
R1, R3, R5, R6, R9, R10: 330; R_0805
R2, R4, R7, R8, R11, R12: 10k; R_0805
U1: LM1117-SOT; TO-220
U2: ESP32_DEVKITC

Connections:
+5V: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), J1.3, J2.3, J4.3, J5.3, J7.3, K1.5, K2.5, K3.5, K4.5, K5.5, K6.5, LED1.1 (A), LED2.1 (A), LED3.1 (A), LED4.1 (A), LED5.1 (A), LED6.1 (A), U1.2 (VOUT)
+12C: J8.2, K2.3, K3.3, K4.3, K5.3, K6.3, U1.3 (VIN)
/C: J6.1, J10.2, J11.2, J12.2, J13.2, K1.1, K2.1, K3.1, K4.1, K5.1, K6.1
/IN1: J1.2, U2.30 (IO18)
/IN2: J2.2, U2.29 (IO5)
/IN3: J4.2, U2.28 (IO17)
/IN4: J7.2, U2.27 (IO16)
/IN5: J5.2, U2.26 (IO4)
/NA: J6.2, K1.3
/OUT1: Q5.1 (G), R11.1, U2.13 (IO12)
/OUT2: Q6.1 (G), R12.1, U2.15 (IO13)
/OUT3: Q4.1 (G), R8.1, U2.16 (SD2)
/OUT4: Q3.1 (G), R7.1, U2.17 (SD3)
/OUT5: Q1.1 (G), R2.1, U2.18 (CMD)
/OUT6: Q2.1 (G), R4.1, U2.5 (IO34)
GND: J1.1, J2.1, J4.1, J5.1, J7.1, J8.1, J10.1, J11.1, J12.1, J13.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), R2.2, R4.2, R7.2, R8.2, R11.2, R12.2, U1.1 (ADJ/GND), U2.14 (GND), U2.38 (GND)
unnamed: K1.2, Q1.2 (D), R1.2
unnamed: K2.2, Q2.2 (D), R3.2
unnamed: K3.2, Q3.2 (D), R5.2
unnamed: K4.2, Q4.2 (D), R6.2
unnamed: K5.2, Q5.2 (D), R9.2
unnamed: K6.2, Q6.2 (D), R10.2
unnamed: LED1.2 (K), R1.1
unnamed: LED2.2 (K), R3.1
unnamed: LED3.2 (K), R5.1
unnamed: LED4.2 (K), R6.1
unnamed: LED5.2 (K), R9.1
unnamed: LED6.2 (K), R10.1

Notes on the sheet:
Bornera y Relay Luz UV
Borneras S. Humedad (suelo)
Bornera S.Humedad/Temp. (DHT11)
Bornera y Relay Elec. Válvulas
¿¿¿Bornera ("Ventilador")???
Microcontrolador (ESP32)
Borneras y Relay para Elec. Válculas
Regulador de tensión (7805)
Bornera y Relay (bomba)
Bornera entrada 12V

Board: 2 copper layers, 96.5 x 104.5 mm, 54 parts (18 on the bottom side), 28 nets.

## Commit log

2022-05-28 proyecto-v1.0.0
